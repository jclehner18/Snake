# Keil uVision project snake.Target_1.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: snake
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -Wno-documentation -Wno-documentation-unknown-command -Wno-license-management -Wno-packed -Wno-parentheses-equality -Wno-reserved-id-macro -Wno-unused-macros -xc
  memory RVCT4: RAM 0x8000000 size 0x10000
  memory RVCT9: ROM 0x20000000 size 0x2000
  scatter file: ./snake.Target 1.sct
  link misc: --entry=Reset_Handler --info summarysizes --load_addr_map_info --summary_stderr
  group Source Group 1
    ../: display.c game.c
    ../../Downloads/knob_working/: fsm_btn.c fsm_btn.h knob.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
